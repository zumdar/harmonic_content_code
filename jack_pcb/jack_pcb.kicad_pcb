# Repository zumdar/harmonic_content_code

File README.md:

# harmonic_content_code
code and software documentation for the Harmonic Content installation

this is the documentation for the interactive art installation

# teensy pinouts
TBD

## KiCad design jack_pcb/jack_pcb.kicad_pcb

Board: 2 copper layers, 200.0 x 127.5 mm, 132 parts (91 on the bottom side), 160 nets.

Parts:
C1, C3, C5, C7, C8, C9, C10, C11, C12, C13, C14, C15, C16, C17, C18, C19, C20, C21, C22, C23, C24, C25, C26, C27, C28, C29, C30, C31, C32, C33, C34, C35, C36, C37, C38: .1uF; C_Axial_L3.8mm_D2.6mm_P7.50mm_Horizontal
C2, C4, C6: 10uF Tantalum; C_Axial_L3.8mm_D2.6mm_P7.50mm_Horizontal
D1: 1N914; D_DO-35_SOD27_P7.62mm_Horizontal
J1, J2, J3, J4, J5, J6, J7, J8, J10, J11, J12, J13, J14, J15, J16, J17, J18, J19, J20, J21, J22, J23, J24, J25, J27, J28, J29, J30, J31, J32, J33, J34: PJ301M-12
J9: Conn_02x16_Odd_Even; PinSocket_2x16_P2.54mm_Vertical
J26: Conn_02x25_Odd_Even; PinSocket_2x25_P2.54mm_Vertical
J35, J36, J37: DIN-5; PinSocket_1x05_P2.54mm_Vertical
J38, J39, J40, J41, J42, J43, J44, J45: RJ45; RJ45_Amphenol_54602-x08_Horizontal
J46: USB_B; USB_B_TE_5787834_Vertical
J47, J48: Conn_01x24; PinHeader_1x24_P2.54mm_Vertical
R1, R2, R3, R4: 220; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R5, R6: 280; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R7, R8, R9, R10, R11, R12, R13, R14, R15, R16, R17, R18, R19, R20, R21, R22, R23, R24, R25, R26, R27, R28, R29, R30, R31, R32, R33, R34, R35, R36, R37, R38: 1000; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
U1: 74HC14; DIP-14_W7.62mm_Socket_LongPads
U2: 6N138; DIP-8_W7.62mm_Socket
U3, U4, U5, U6: 74125; DIP-14_W7.62mm_Socket
U7: Teensy4.1; Teensy41

Connections:
+3V3: C5.1, C6.1, J9.9, J9.11, J40.7, J40.8, J41.7, J41.8, J44.7, J44.8, J45.7, J45.8
+5V: C1.1, C2.1, J9.5, J9.7, J39.7, J39.8, J43.7, J43.8, J48.1, R1.2, R2.1, R6.1, U1.14, U3.14, U4.14, U5.14, U6.14, U7.48
+12V: C3.1, C4.1, J9.1, J9.3, J38.7, J38.8, J42.7, J42.8
/MIDI_NEG: D1.1, J36.4, U2.2
/MIDI_POS: J36.5, R5.1
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.1, C8.1, C9.1, C10.1, C11.1, C12.1, C13.1, C14.1, C15.1, C16.1, C17.1, C18.1, C19.1, C20.1, C21.1, C22.1, C23.1, C24.1, C25.1, C26.1, C27.1, C28.1, C29.1, C30.1, C31.1, C32.1, C33.1, C34.1, C35.1, C36.1, C37.1, C38.1, J1.3, J2.3, J3.3, J4.3, J5.3, J6.3, J7.3, J8.3, J9.21, J9.23, J9.25, J9.27, J9.29, J9.31, J10.3, J11.3, J12.3, J13.3, J14.3, J15.3, J16.3, J17.3, J18.3, J19.3, J20.3, J21.3, J22.3, J23.3, J24.3, J25.3, J26.41, J26.42, J26.43, J26.44, J26.45, J26.46, J26.47, J26.48, J26.49, J26.50, J27.3, J28.3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
IN1: J9.2, J40.3
IN2: J9.4, J40.4
IN3: J9.6, J40.5
IN4: J9.8, J40.6
IN5: J9.10, J44.3
IN6: J9.12, J44.4
IN7: J9.14, J44.5
IN8: J9.16, J44.6
IN9: J9.18, J41.3
IN10: J9.20, J41.4
IN11: J9.22, J41.5
IN12: J9.24, J41.6
IN13: J9.26, J45.3
IN14: J9.28, J45.4
IN15: J9.30, J45.5
IN16: J9.32, J45.6
LED1: J39.3, U5.3
LED2: J39.4, U5.11
LED3: J39.5, U5.6
LED4: J39.6, U5.8
LED5: J43.3, U6.3
LED6: J43.4, U6.11
LED7: J43.5, U6.6
LED8: J43.6, U6.8
LEDOUT1: J47.16, U5.2, U7.16
LEDOUT2: J47.17, U5.12, U7.17
LEDOUT3: J47.18, U5.5, U7.18
LEDOUT4: J47.19, U5.9, U7.19
LEDOUT5: J47.20, U6.2, U7.20
LEDOUT6: J47.21, U6.12, U7.21
LEDOUT7: J47.22, U6.5, U7.22
LEDOUT8: J47.23, U6.9, U7.23
MIDIREC: J9.17, R6.2, U1.9, U2.8
MIDITRANS: J9.19, U1.3
MOTOR1: J38.3, U3.3
MOTOR2: J38.4, U3.11
MOTOR3: J38.5, U3.6
MOTOR4: J38.6, U3.8
MOTOR5: J42.3, U4.3
MOTOR6: J42.4, U4.11
MOTOR7: J42.5, U4.6
MOTOR8: J42.6, U4.8
unnamed: D1.2, R5.2, U2.3
unnamed: J35.4, R1.1
unnamed: J35.5, R3.1
unnamed: J37.4, R2.2
unnamed: J37.5, R4.1
unnamed: J46.1, U7.55
unnamed: J46.2, U7.56
unnamed: J46.3, U7.57
unnamed: J47.2, U7.2
unnamed: J47.3, U7.3
unnamed: J47.12, U7.12
unnamed: J47.13, U7.13
unnamed: J47.14, U7.14
unnamed: J47.15, U7.15
unnamed: J47.24, U7.24
unnamed: J48.3, U7.46
unnamed: J48.4, U7.45
unnamed: J48.5, U7.44
unnamed: J48.6, U7.43
unnamed: J48.7, U7.42
unnamed: J48.10, U7.39
unnamed: J48.11, U7.38
unnamed: J48.12, U7.37
unnamed: J48.13, U7.36
unnamed: J48.14, U7.35
unnamed: J48.16, U7.33
unnamed: J48.17, U7.32
unnamed: J48.18, U7.31
unnamed: J48.19, U7.30
unnamed: J48.20, U7.29
unnamed: J48.21, U7.28
unnamed: J48.22, U7.27
unnamed: J48.23, U7.26
unnamed: J48.24, U7.25
unnamed: R3.2, U1.6
unnamed: R4.2, U1.2
unnamed: U1.1, U1.4
unnamed: U1.5, U1.8
PWMOUT1: J47.4, U3.2, U7.4
PWMOUT2: J47.5, U3.12, U7.5
PWMOUT3: J47.6, U3.5, U7.6
PWMOUT4: J47.7, U3.9, U7.7
PWMOUT5: J47.8, U4.2, U7.8
PWMOUT6: J47.9, U4.12, U7.9
PWMOUT7: J47.10, U4.5, U7.10
PWMOUT8: J47.11, U4.9, U7.11
SCL: J9.13, J48.8, U7.41
SDA: J9.15, J48.9, U7.40
V0: J2.1, R7.2
V1: J3.1, R8.1
V2: J4.1, R9.1
V3: J5.1, R10.1
V4: J6.1, R11.1
V5: J7.1, R12.1
V6: J8.1, R13.1
V7: J1.1, R14.1
V8: J11.1, R15.1
V9: J12.1, R16.1
V10: J13.1, R17.1
V11: J14.1, R18.1
V12: J15.1, R19.1
V13: J16.1, R20.1
V14: J17.1, R21.1
V15: J10.1, R22.1
V16: J19.1, R23.1
V17: J20.1, R32.1
V18: J21.1, R33.1
V19: J22.1, R34.1
V20: J23.1, R35.1
V21: J24.1, R36.1
V22: J25.1, R37.1
V23: J18.1, R38.1
V24: J28.1, R24.1
V25: J29.1, R25.1
V26: J30.1, R26.1
V27: J31.1, R27.1
V28: J32.1, R28.1
V29: J33.1, R29.1
V30: J34.1, R30.1
V31: J27.1, R31.1
VDAC0: C8.2, J26.1, R7.1
VDAC1: C7.2, J26.2, R8.2
VDAC2: C9.2, J26.3, R9.2
VDAC3: C10.2, J26.4, R10.2
VDAC4: C11.2, J26.5, R11.2
VDAC5: C12.2, J26.6, R12.2
VDAC6: C13.2, J26.7, R13.2
VDAC7: C14.2, J26.8, R14.2
VDAC8: C15.2, J26.9, R15.2
VDAC9: C16.2, J26.10, R16.2
VDAC10: C17.2, J26.11, R17.2
VDAC11: C18.2, J26.12, R18.2
VDAC12: C19.2, J26.13, R19.2
VDAC13: C20.2, J26.14, R20.2
VDAC14: C21.2, J26.15, R21.2
VDAC15: C22.2, J26.16, R22.2
VDAC16: C23.2, J26.17, R23.2
VDAC17: C32.2, J26.18, R32.2
VDAC18: C33.2, J26.19, R33.2
VDAC19: C34.2, J26.20, R34.2
VDAC20: C35.2, J26.21, R35.2
VDAC21: C36.2, J26.22, R36.2
VDAC22: C37.2, J26.23, R37.2
VDAC23: C38.2, J26.24, R38.2
VDAC24: C24.2, J26.25, R24.2
VDAC25: C25.2, J26.26, R25.2
VDAC26: C26.2, J26.27, R26.2
VDAC27: C27.2, J26.28, R27.2
VDAC28: C28.2, J26.29, R28.2
VDAC29: C29.2, J26.30, R29.2
VDAC30: C30.2, J26.31, R30.2
VDAC31: C31.2, J26.32, R31.2

## KiCad design CentralPCB/CentralPCB.kicad_pcb

Parts:
C1, C2, C3, C4, C6: .1u; C_0805_2012Metric
C5: .33u; C_0805_2012Metric
D1, D3: 12V_POW; LED_D3.0mm
D2: 5V_POW; LED_D3.0mm
D4, D5, D6, D7: POW; LED_D3.0mm
D8, D9, D10, D11, D12, D13, D14, D15, D16, D17, D18, D19, D20, D21, D22, D23: 3.3v Zener; D_SOD-123
J1: POWER HEADER; PinSocket_2x08_P2.54mm_Vertical
J2: SPI Header; PinSocket_1x04_P2.54mm_Vertical
J3, J4: Conn_01x24; PinSocket_1x24_P2.54mm_Vertical
J5: Conn_02x16_Odd_Even; PinSocket_2x16_P2.54mm_Vertical
J6: Conn_Coaxial; SMB_Jack_Vertical
J7: Conn_02x10_Odd_Even; PinSocket_2x10_P2.54mm_Vertical
J8: Conn_01x05; PhoenixContact_GMSTBVA-G_05x7.50mm_Vertical
R1, R2, R3, R5, R6, R7, R8: ?; R_0805_2012Metric
R4: 10k; R_0805_2012Metric
R9, R10, R11, R12, R13, R14, R15, R16, R17, R18, R19, R20, R21, R22, R23, R24: 200; R_0805_2012Metric
TH1, TH2, TH3: Thermistor_US; R_1206_3216Metric
U1: AD8531; SOIC-8_3.9x4.9mm_P1.27mm
U2: Teensy4.1; Teensy41
U3: BA7810CP-E2; TO-220-3_Vertical

Connections:
+3V3: C4.2, J5.9, J5.11, R5.1, R6.1, R7.1, R8.1, U1.2 (-), U1.6
+5V: J4.1, J5.5, J5.7, J8.2, R2.1, TH2.2, U1.7 (V+), U2.48
+10V: C6.1, J6.1 (In), U3.3 (VOUT)
+12V: C5.1, J5.1, J5.3, J8.4, R3.1, TH1.2, U3.1 (VIN)
-12V: J8.5, R1.1, TH3.2
CLR: J3.24, J7.10, U2.24
CS0: J2.4, J3.12, J7.6, U2.12
DA1: D8.1 (K), J4.13, R9.2, U2.36
DA2: D9.1 (K), J4.12, R10.2, U2.37
DA3: D10.1 (K), J4.11, R11.2, U2.38
DA4: D11.1 (K), J4.10, R12.2, U2.39
DB1: D12.1 (K), J4.7, R13.2, U2.42
DB2: D13.1 (K), J4.6, R14.2, U2.43
DB3: D14.1 (K), J4.5, R15.2, U2.44
DB4: D15.1 (K), J4.4, R16.2, U2.45
DC1: D16.1 (K), J3.16, R17.2, U2.16
DC2: D17.1 (K), J3.17, R18.2, U2.17
DC3: D18.1 (K), J3.18, R19.2, U2.18
DC4: D19.1 (K), J3.19, R20.2, U2.19
DD1: D20.1 (K), J4.19, R21.2, U2.30
DD2: D21.1 (K), J4.18, R22.2, U2.31
DD3: D22.1 (K), J4.17, R23.2, U2.32
DD4: D23.1 (K), J4.16, R24.2, U2.33
GND: C1.2, C2.2, C3.2, C5.2, C6.2, D1.1 (K), D2.1 (K), D3.1 (K), D8.2 (A), D9.2 (A), D10.2 (A), D11.2 (A), D12.2 (A), D13.2 (A), D14.2 (A), D15.2 (A), D16.2 (A), D17.2 (A), D18.2 (A), D19.2 (A), D20.2 (A), D21.2 (A), D22.2 (A), D23.2 (A), J1.3, J1.4, J1.5, J1.6, J1.7, J1.8, J3.1, J4.2, J4.15, J5.21, J5.23, J5.25, J5.27, J5.29, J5.31, J6.2 (Ext), J7.7, J7.9, J7.11, J7.13, J7.15, J7.17, J7.19, J8.1, J8.3, U1.4 (V-), U2.1, U2.34, U2.47, U2.52, U2.58, U2.59, U2.64, U3.2 (GND)
LDAC: J3.23, J7.8, U2.23
MIDIREC: J3.9, U2.9
MIDITRANS: J3.10, J5.19, U2.10
MIDREC: J5.17
MISO0: J2.2, J3.14, J7.12, U2.14
MOSI0: J2.3, J3.13, J7.1, U2.13
unnamed: C1.1, J1.1, J1.2, TH3.1
unnamed: C2.1, J1.11, J1.12, TH2.1
unnamed: C3.1, J1.9, J1.10, TH1.1
unnamed: C4.1, R4.1, U1.3 (+)
unnamed: D1.2 (A), R1.2
unnamed: D2.2 (A), R2.2
unnamed: D3.2 (A), R3.2
unnamed: D4.1 (K), J3.4, U2.4
unnamed: D4.2 (A), R5.2
unnamed: D5.1 (K), J3.5, U2.5
unnamed: D5.2 (A), R6.2
unnamed: D6.1 (K), J3.6, U2.6
unnamed: D6.2 (A), R7.2
unnamed: D7.1 (K), J3.7, U2.7
unnamed: D7.2 (A), R8.2
unnamed: J3.2, U2.2
unnamed: J3.3, U2.3
unnamed: J3.8, U2.8
unnamed: J3.11, U2.11
unnamed: J3.15, U2.15
unnamed: J3.20, U2.20
unnamed: J3.21, U2.21
unnamed: J4.3, R4.2, U2.46
unnamed: J4.20, U2.29
unnamed: J4.21, U2.28
unnamed: J4.22, U2.27
unnamed: J4.23, U2.26
unnamed: J4.24, U2.25
unnamed: J5.2, R9.1
unnamed: J5.4, R10.1
unnamed: J5.6, R11.1
unnamed: J5.8, R12.1
unnamed: J5.10, R13.1
unnamed: J5.12, R14.1
unnamed: J5.14, R15.1
unnamed: J5.16, R16.1
unnamed: J5.18, R17.1
unnamed: J5.20, R18.1
unnamed: J5.22, R19.1
unnamed: J5.24, R20.1
unnamed: J5.26, R21.1
unnamed: J5.28, R22.1
unnamed: J5.30, R23.1
unnamed: J5.32, R24.1
RESET: J3.22, J7.14, U2.22
SCK0: J2.1, J4.14, J7.3, U2.35
SCL: J4.8, J5.13, U2.41
SDA: J4.9, J5.15, U2.40

Board: 2 copper layers, 76.2 x 81.3 mm, 71 parts (0 on the bottom side), 77 nets.

Other parts of the board:
 : MountingHole_3mm_Pad
 #2,  #3,  #4: MountingHole_3mm_Pad

## Code that names these connections

File main/DAC_Test/DAC_Test.ino:

#include <SPI.h>

// SPI 0
const int CS0 = 10;
const int MISO0 = 12;
const int MOSI0 = 11;
const int SCK0 = 13;

#define LDAC 23
#define CLEAR 24
#define RESET 22

#define VMIN          21844
#define VMAX          65535

int attackInterval = 500;
int releaseInterval = 500;
byte header = 0b00000000; // first two 4 bits are 0000 -- disable toggle mode, enable write , then two blank
byte address =1;   // this is just 4 bits but we will OR it with header
word regi = 0b1100000000000000; // need the first 2 bits of the data word to be 11 to select the input data register
word value; // this will be a 14 bit number, go up to 16384.
byte valueHighByte;
byte valueLowByte;

bool note;
int runtime;

/*
 * DAC SPI data transfer
 * @param address: address of data
 * @param value: value to be sent
 */
int dacWrite(int address, int value) {
  byte beginning = (header | address); // create the 1st byte
  word data = (regi | value); // create the next 2 bytes
  valueHighByte = highByte(data);
  valueLowByte = lowByte(data);
  // take the SS pin low to select the chip:
  digitalWrite(CS0, LOW);
  SPI.transfer(beginning);
  SPI.transfer(valueHighByte);
  SPI.transfer(valueLowByte);
  // take the SS pin high to de-select the chip:
  digitalWrite(CS0, HIGH);
  return 0;
}

void playNote(bool note)
{
  static int prevNote = true;
  static int prevAmp = 21844;
  //If note being played
  if(note)
  {
    if (prevAmp < 65535)
    {
      prevAmp += attackInterval;
      Serial.print(prevAmp);
      Serial.print("\n");
      dacWrite(1, prevAmp);
    }
  }
  else 
  {
    //Release
    if (prevAmp > 21844)
    {
      prevAmp -= releaseInterval;
      Serial.print(prevAmp);
      Serial.print("\n");
      dacWrite(1, prevAmp);
    }
  }
}

void setup() {
  // put your setup code here, to run once:
  note = true;
  runtime = millis();
  Serial.begin(9600);
  pinMode (CS0, OUTPUT);SPI.begin();
  digitalWrite (CS0, HIGH);
  SPI.beginTransaction(SPISettings(140000000, MSBFIRST, SPI_MODE1));
}

void loop() {
  // put your main code here, to run repeatedly:
  if(millis() - runtime > 7000)
  {
    note = !note;
    runtime = millis();
    Serial.print("Cycling\n");
  }
  
  playNote(note);
  delay(40);

}

File main/display/display.ino:

#include <Arduino.h>
#include <i2c_driver.h>
#include <i2c_driver_wire.h>

#include <Adafruit_NeoPixel.h>

#define NUMPIXELS 80 // Popular NeoPixel ring size

#define MOTOR1 2 // pin 2 for motor1
#define MOTOR2 3 // pin 2 for motor1
#define MOTOR3 4 // pin 2 for motor1
#define MOTOR4 5 // pin 2 for motor1

Adafruit_NeoPixel pixels1(NUMPIXELS, 24, NEO_GRB + NEO_KHZ800);
Adafruit_NeoPixel pixels2(NUMPIXELS, 25, NEO_GRB + NEO_KHZ800);
Adafruit_NeoPixel pixels3(NUMPIXELS, 26, NEO_GRB + NEO_KHZ800);
Adafruit_NeoPixel pixels4(NUMPIXELS, 27, NEO_GRB + NEO_KHZ800);

#define DELAYVAL 100 // Time (in milliseconds) to pause between pixels

//Private variables-----------------------------------------------------
int note[] = {24, 24, 24, 24};
int amp[] = {0, 0, 0, 0};
int osc1, osc2, osc3, osc4, motor1speed, motor2speed, motor3speed, motor4speed;

void setup()
{
  pinMode(MOTOR1, OUTPUT);
  pinMode(MOTOR2, OUTPUT);
  pinMode(MOTOR3, OUTPUT);
  pinMode(MOTOR4, OUTPUT);
  pixels1.begin(); // INITIALIZE NeoPixel strip object (REQUIRED)
  pixels2.begin(); // INITIALIZE NeoPixel strip object (REQUIRED)
  pixels3.begin(); // INITIALIZE NeoPixel strip object (REQUIRED)
  pixels4.begin(); // INITIALIZE NeoPixel strip object (REQUIRED)
  Wire.begin(9);                // join i2c bus with address #9
  Wire.onReceive(receiveEvent); // register event
  Serial.begin(9600);           // start serial for output
}

void loop()
{
  osc1 = map(note[0], 24, 48, 0, 255);
  osc2 = map(note[1], 24, 48, 0, 255);
  osc3 = map(note[2], 24, 48, 0, 255);
  osc4 = map(note[3], 24, 48, 0, 255);
//  motor1speed = map(note[0], 24, 48, 100, 200);
//  motor2speed = map(note[1], 24, 48, 100, 200);
//  motor3speed = map(note[2], 24, 48, 100, 200);
//  motor4speed = map(note[3], 24, 48, 100, 200);
//
//
//  analogWrite(MOTOR1, motor1speed);
//  analogWrite(MOTOR2, motor2speed);
//  analogWrite(MOTOR3, motor3speed);
//  analogWrite(MOTOR4, motor4speed);

  pixels1.clear(); // Set all pixel colors to 'off'
  pixels2.clear(); // Set all pixel colors to 'off'
  pixels3.clear(); // Set all pixel colors to 'off'
  pixels4.clear(); // Set all pixel colors to 'off'

  // The first NeoPixel in a strand is #0, second is 1, all the way up
  // to the count of pixels minus one.
  for (int i = 0; i < NUMPIXELS; i++) { // For each pixel...

    // pixels.Color() takes RGB values, from 0,0,0 up to 255,255,255
    // Here we're using a moderately bright green color:
    //    pixels1.setPixelColor(i, pixels1.Color(255, 0, 40));
    pixels1.setPixelColor(i, pixels1.Color(osc1, 100, 0));
    pixels2.setPixelColor(i, pixels2.Color(0, osc2, 20));
    pixels3.setPixelColor(i, pixels3.Color(0, 10, osc3));
    pixels4.setPixelColor(i, pixels4.Color(osc4, osc4, 70));
  }

  pixels1.show();   // Send the updated pixel colors to the hardware.
  pixels2.show();   // Send the updated pixel colors to the hardware.
  pixels3.show();   // Send the updated pixel colors to the hardware.
  pixels4.show();   // Send the updated pixel colors to the hardware.

  delay(100);
}

void receiveEvent(int howMany)
{
  char c = Wire.read(); // a
  Serial.print(c);
  int oscil = Wire.read(); //oscil number
  Serial.print(oscil);
  Serial.print(":");
  c = Wire.read(); // :
  note[oscil] = Wire.read(); // pitch
  Serial.print(note[oscil]);
  Serial.print(":");
  c = Wire.read(); // :
  amp[oscil] = Wire.read(); // vol
  Serial.print(amp[oscil]);
  Serial.print("\n");
  //message in a<oscil>:<note>:<vol> format
}

## Commit log

2021-04-19 initial adds. code from fall 2019 and spring 2021
2021-04-19 readme
2021-09-29 main function added
2021-10-05 first jack pcb
2021-10-05 jack pcb work
2021-10-09 pin assignments
2021-10-09 Added CentralPCB board
2021-10-11 self tuning
2021-10-20 attack and delay
2021-10-20 Updated user interface pins
2021-10-20 Fixed diodes
2021-10-22 PCB update
2021-10-22 Fixed Teensy connections
2021-10-22 jack pcb update
2021-10-22 Consolidated pin headers
2021-10-25 Updated DAC connections
2021-10-25 Pin updates
2021-10-25 small pcb changes
2021-10-26 Changed phoenix connector
2021-10-26 -12v LED
2021-10-26 Revert "Sav"
2021-10-26 Squashed commit of the following:
    commit 4cc6f9daa43c8e58e4c19e3ea2c52996bd638c5b
    Author: SavHearn <sav.hearn@gmail.com>
    Date: Tue Oct 26 14:19:17 2021 -0400
    Auto generated file
2021-10-26 Fixed glitched CentralPCB schematic
2021-10-27 Began CentralPCB layout
2021-10-27 jack board updates
2021-10-27 DAC test
2021-10-27 remove error
2021-10-27 More routing CentralPCB
2021-10-29 Finished CentralPCB
2021-10-29 Added additional protection for CentralPCB
2021-10-30 jack board modifications
2021-10-30 small silkscreen changes on centralpcb
2021-10-31 finalized jack board
2021-11-01 gerbers and small finalizations to boards
2021-11-10 dac changes
2021-11-15 testing
2021-11-19 update for midi
2021-11-26 I2C setup
2021-12-06 display driver
2021-12-07 debugging changes
2021-12-07 Good main
2021-12-10 adding website stuff
2021-12-10 changing readme
2021-12-10 small
2021-12-11 update to webpage
2021-12-11 website updates
2021-12-14 temp website
2021-12-16 finishing up website
